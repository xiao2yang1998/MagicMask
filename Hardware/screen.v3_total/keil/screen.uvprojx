# Keil uVision project screen.uvprojx, settings and files
target screen (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MSP432P401R Texas Instruments
  pack: TexasInstruments.MSP432P4xx_DFP.3.2.5
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x01000000,0x00010000) IROM(0x00000000,0x00040000) IROM2(0x00200000,0x00004000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: screen
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: __MSP432P401R__
  c include: ..\source\third_party\CMSIS\Include;..\source;..\..\screen;..\source\ti\devices\msp432p4xx\driverlib;..\helper\cjson
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1000000 size 0x10000
  group startup
    ../source/ti/devices/msp432p4xx/startup_system_files/: system_msp432p401r.c
    ../source/ti/devices/msp432p4xx/startup_system_files/keil/: startup_msp432p401r_uvision.s
    ./: hardware.s
  group lib
    ../source/ti/devices/msp432p4xx/driverlib/keil/: msp432p4xx_driverlib.lib
  group user
    ../: tick.c led.c alicloud_feiYan.c userButton.c aliConfig.c uart1.c hsb2rgb.c json.c hardware.h queue.c queue.h sensirion_common.c sgp_git_version.c sgp30_featureset.c sensirion_arch_config.h sensirion_common.h sgp_featureset.h sgp_git_version.h sgp30.h main.c sgp30.c bme280.c i2c_driver.h i2c_driver.c MAX303100.c oled.c i2c.c
